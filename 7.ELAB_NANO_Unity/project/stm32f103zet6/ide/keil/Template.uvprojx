# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\..\..\mcu\stm32f103zet6\STM32F1xx_HAL_Driver\Inc;..\..\..\..\mcu\stm32f103zet6\CMSIS\Include;..\..\..\..\mcu\stm32f103zet6\CMSIS\Device\ST\STM32F1xx\Include;..\..\usr\bsp;..\..\usr\core;..\..\..\..\elab\elib;..\..\..\..\elab\common;..\..\..\..\elab\3rd\list;..\..\..\..\elab\3rd\lwrb;..\..\..\..\elab\3rd\ringbuf;..\..\..\..\elab\3rd\state_machine;..\..\..\..\elab\3rd\xfusion\xf_common;..\..\..\..\elab\3rd\xfusion\xf_utils_log;..\..\..\..\elab\3rd\xfusion;..\..\..\..\elab\3rd\Shell;..\..\..\..\elab\os\mcu_os;..\..\..\..\elab\os;..\..\..\..\elab\3rd\FreeRTOS\include;..\..\..\..\elab\3rd\FreeRTOS\portable\RVDS\ARM_CM3;..\..\usr;..\..\..\..\elab\3rd\Unity
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Template.sct
  group usr
    ../../usr/: main.c elab_config.h FreeRTOSConfig.h
  group core
    ../../usr/core/: stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../../../../mcu/stm32f103zet6/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../../../mcu/stm32f103zet6/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group bsp
    ../../usr/bsp/: bsp.c debug_uart.c
  group unity_test
    ../../usr/unity_test/: test_demo.c unity_export.c
  group stm32f1_hal
    ../../../../mcu/stm32f103zet6/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_cortex.c
    ../../../../mcu/stm32f103zet6/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_conf.h
  group elab/elib
    ../../../../elab/elib/: elib_crc.c elib_queue.c hash_table.c
  group elab/common
    ../../../../elab/common/: elab_assert.c elab_common.c elab_log.c elab_export.c
  group 3rd/xfusion
    ../../../../elab/3rd/xfusion/xf_utils_log/: xf_utils_log_dump.c
  group 3rd/component
    ../../../../elab/3rd/list/: list.c list_iterator.c list_node.c
    ../../../../elab/3rd/lwrb/: lwrb.c
    ../../../../elab/3rd/ringbuf/: ringbuf.c
    ../../../../elab/3rd/state_machine/: state_machine.c
  group 3rd/shell
    ../../../../elab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group 3rd/unity
    ../../../../elab/3rd/Unity/: unity.c unity_fixture.c unity_memory.c
  group os/freertos
    ../../../../elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../elab/3rd/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../../elab/3rd/FreeRTOS/portable/MemMang/: heap_4.c
  group os/cmsis
    ../../../../elab/os/mcu_os/: cmsis_os2.c
